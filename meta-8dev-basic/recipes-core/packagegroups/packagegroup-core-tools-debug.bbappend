RDEPENDS:${PN}:append:8dev-basic = " usbutils"
