# Built-in public-suffix list instead of the libicu runtime (drops the libicu dep).
PACKAGECONFIG:8dev-basic = ""
